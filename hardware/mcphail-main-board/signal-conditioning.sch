File: hardware/mcphail-main-board/signal-conditioning.sch (KiCad schematic (older format))
At the start: 41 parts, among them J2 OPTO SENSOR, J3 OPTO BRKOUT, U1 MCP6004, U2 MCP6004, U4 MCP6004, U5 TLV274

Commit message: Release main board sch with BOM and layout estimates.
Parts:
- removed J2: OPTO SENSOR, CONN-1x03-2.54MM-TH, symbol HEADER-MALE-3POS-TH-1x03-P0.1IN
- removed J3: OPTO BRKOUT, CONN-1x05-2.54MM-TH, symbol HEADER-MALE-5POS-TH-1x05-P0.1IN
- added C1: 330uF, Wickerlib:CAP-RADIAL-ALUM-D6.3MM-P2.5MM, symbol CAP-CER-330UF-16V-20%-ALUM-RADIAL
- added C10, C3: 270nF, Wickerlib:RLC-0603-SMD, symbol CAP-CER-270NF-16V-X7R-0603
- added C2: DNP, Wickerlib:RLC-1206-SMD, symbol CAP-CER-1.5UF-25V-X7R-1206
- added C5: 39nF, Wickerlib:RLC-0603-SMD, symbol CAP-CER-39NF-50V-X7R-0603
- added J1: INSECT DETECTION, Wickerlib:CONN-HEADER-STRAIGHT-P2.54MM-1x02, symbol HEADER-MALE-2POS-TH-1x02-P0.1IN
- added J2: EMITTERS, Wickerlib:CONN-HEADER-STRAIGHT-P2.54MM-1x02, symbol HEADER-MALE-2POS-TH-1x02-P0.1IN
- added J3: BREAKOUT, Wickerlib:CONN-HEADER-STRAIGHT-P2.54MM-1x06, symbol HEADER-MALE-KK100-1x06-0.1IN-SHROUD-TH
- added R1: 220, Wickerlib:RLC-0603-SMD, symbol RES-220-5%-1/10W-0603
- added R10: 732, Wickerlib:RLC-0603-SMD, symbol RES-732-1%-1/10W-0603
- added R11, R8: 1.43K, Wickerlib:RLC-0603-SMD, symbol RES-1.43K-1%-1/10W-0603
- added R15: 97.6K, Wickerlib:RLC-0603-SMD, symbol RES-97.6K-1%-1/10W-0603
- added R17: 68, Wickerlib:RLC-0603-SMD, symbol RES-68-1%-1/10W-0603
- added R18, R19: 91K, Wickerlib:RLC-0603-SMD, symbol RES-91K-1%-1/10W-0603
- added R2: 64.9K, Wickerlib:RLC-0603-SMD, symbol RES-64.9K-1%-1/10W-0603
- added R22, R26: 2.2K, Wickerlib:RLC-0603-SMD, symbol RES-2.2K-5%-1/10W-0603
- added R24, R28: 22K, Wickerlib:RLC-0603-SMD, symbol RES-22K-5%-1/10W-0603
- added R25, R29: 4.32K, Wickerlib:RLC-0603-SMD, symbol RES-4.32K-1%-1/10W-0603
- added R27: 2.94K, Wickerlib:RLC-0603-SMD, symbol RES-2.94K-1%-1/10W-0603
- added R30, R6: 3.83K, Wickerlib:RLC-0603-SMD, symbol RES-3.83K-1%-1/10W-0603
- added R5: 1.87K, Wickerlib:RLC-0603-SMD, symbol RES-1.87K-1%-1/10W-0603
- added unit 1 of U1
- C14: renamed from C9; footprint Wickerlib:RLC-0805 -> Wickerlib:RLC-0805-SMD
- C22: renamed from C17; value CAP-CER-2.2UF-25V-X7R-0805 -> 2.2uF
- C25: renamed from C20; footprint Wickerlib:RLC-0805 -> Wickerlib:RLC-0805-SMD
- C29: renamed from C24; footprint Wickerlib:RLC-0805 -> Wickerlib:RLC-0805-SMD
- C4: renamed from C1; footprint Wickerlib:RLC-0805 -> Wickerlib:RLC-0805-SMD
- C9: renamed from C5; footprint Wickerlib:RLC-0805 -> Wickerlib:RLC-0805-SMD
- R12: renamed from R5; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R13: renamed from R6; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R14: renamed from R7; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R16: renamed from R8; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R20, R21: renamed from R?; footprint RLC-0805-SMD -> Wickerlib:RLC-0805-SMD
- R23: renamed from R9; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R3: renamed from R1; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R4: renamed from R2; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R7: renamed from R3; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- R9: renamed from R4; footprint RLC-0603-SMD -> Wickerlib:RLC-0603-SMD
- renumbered C6 to C11, C7 to C12, C8 to C13, C10 to C15, C11 to C16, C12 to C17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
Connections:
- net labels added: 5V
- wire segments 185 -> 212
Other:
- note added: "EMITTER\nOUTPUT"
- note removed: "1.43K"
- note removed: "1.87K"
- note removed: "2.2K"
- note removed: "2.94K\n"
- note removed: "22K"
- note removed: "270nF"
- note removed: "3.83K\n"
- note removed: "39n\n"
- note removed: "4.32K\n"
- note removed: "68\n"
- note removed: "735"
- note removed: "91K\n"
- note removed: "97.6K"
- note removed: "TODO: might need separate isolated 3.3V here\n"
- moved on the sheet: C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22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

Commit message: Added ADS1118 (ADC with temp sensor) to Atmega32u4.
Other:
- note added: "SHEET 2: SIGNAL CONDITIONING"
Changed lines of the file:
@@
 	3425 5425 3425 8125
 Connection ~ 3700 8125
+Text Notes 4200 1375 0    200  ~ 0
+SHEET 2: SIGNAL CONDITIONING
 $EndSCHEMATC

Commit message: Hooked up pins to ATSAMD21G18 Cortex M0, fixed AGND throughout.
Connections:
- net GND: no longer C14.2, C29.2, C4.2, C6.2, C9.2, J3.6 (P6), R19.2, R4.2, U1.11 (-), U2.11 (-), U3.11 (-), U4.11 (-)
- new net AGND: C14.2, C29.2, C4.2, C6.2, C9.2, J3.6 (P6), R19.2, R4.2, U1.11 (-), U2.11 (-), U3.11 (-), U4.11 (-)

Commit message: Fixed the sigcond sch, VREF now correct.
Parts:
- removed C3: 270nF, Wickerlib:RLC-0603-SMD, symbol CAP-CER-270NF-16V-X7R-0603
- added C3: 220nF, Wickerlib:RLC-0603-SMD, symbol CAP-CER-220NF-25V-X7R-0603
Connections:
- net +5V: now also C3.1
- net GND: now also C3.2
- net VREF: now also C10.2, C27.2, C5.2, C6.1, U1.10 (+), U1.5 (+), U2.12 (+), U4.3 (+)
- net PHOTO_K: now reaches C2.2, J1.1 (P1), R2.2, U1.2 (-)

Commit message: All footprints good. Changed op amps slightly for footprints.
Parts:
- removed unit 1 of U1
- added U4: MCP6001, Wickerlib:SOT-23-5, symbol IC-OPAMP-MCP6001-SOT23-5
- renumbered U2 to U1, U4 to U2, U1 to U2
Connections:
- net +5V: now also U4.5 (+)
- net AGND: now also C3.2, J1.2 (P2), U4.2 (-), U4.3 (+)
- net GND: no longer C3.2, J1.2 (P2)
- net PHOTO_K: now also U4.4 (-)
- net at C2.1, C7.2, R2.1: now also U4.1
Other:
- moved on the sheet: C14

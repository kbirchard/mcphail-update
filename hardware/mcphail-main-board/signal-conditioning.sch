File: hardware/mcphail-main-board/signal-conditioning.sch (KiCad schematic (older format))
At the start: 66 parts, among them J1 INSECT DETECTION, J2 EMITTERS, J3 BREAKOUT, U1 MCP6004, U2 MCP6004, U3 TLV274, U4 MCP6001

Commit message: Reworking main board, power rails routed next.
Connections:
- net +3V3 renamed VDDANA
Changed lines of the file:
@@
 $EndComp
 $Comp
-L +5V #PWR013
+L +5V #PWR012
 U 1 1 596FCAB2
 P 6350 3400
-F 0 "#PWR013" H 6350 3250 50  0001 C CNN
+F 0 "#PWR012" H 6350 3250 50  0001 C CNN
 F 1 "+5V" H 6350 3540 50  0000 C CNN
 F 2 "" H 6350 3400 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR014
+L +5V #PWR013
 U 1 1 596FCB56
 P 3550 4225
-F 0 "#PWR014" H 3550 4075 50  0001 C CNN
+F 0 "#PWR013" H 3550 4075 50  0001 C CNN
 F 1 "+5V" H 3550 4365 50  0000 C CNN
 F 2 "" H 3550 4225 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR015
+L +5V #PWR014
 U 1 1 59701081
 P 12225 3550
-F 0 "#PWR015" H 12225 3400 50  0001 C CNN
+F 0 "#PWR014" H 12225 3400 50  0001 C CNN
 F 1 "+5V" H 12225 3690 50  0000 C CNN
 F 2 "" H 12225 3550 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +3.3V #PWR016
-U 1 1 59713790
-P 9325 7350
-F 0 "#PWR016" H 9325 7200 50  0001 C CNN
-F 1 "+3.3V" H 9325 7490 50  0000 C CNN
-F 2 "" H 9325 7350 50  0000 C CNN
-F 3 "" H 9325 7350 50  0000 C CNN
-	1    9325 7350
-	1    0    0    -1
-$EndComp
-$Comp
 L CAP-CER-4.7UF-50V-X7R-1206 C21
 U 1 1 597161AA
@@
 	1    0    0    -1
 $EndComp
-$Comp
-L +3.3V #PWR017
-U 1 1 59716A30
-P 9550 5950
-F 0 "#PWR017" H 9550 5800 50  0001 C CNN
-F 1 "+3.3V" H 9550 6090 50  0000 C CNN
-F 2 "" H 9550 5950 50  0000 C CNN
-F 3 "" H 9550 5950 50  0000 C CNN
-	1    9550 5950
-	1    0    0    -1
-$EndComp
 Text HLabel 13525 8425 2    50   Output ~ 0
 A2
@@
 Text HLabel 13525 8625 2    50   Output ~ 0
 A0
-Text HLabel 13525 8325 2    50   Input ~ 0
-3.3V
-$Comp
-L +3.3V #PWR018
-U 1 1 5971ADA4
-P 12425 8225
-F 0 "#PWR018" H 12425 8075 50  0001 C CNN
-F 1 "+3.3V" H 12425 8365 50  0000 C CNN
-F 2 "" H 12425 8225 50  0000 C CNN
-F 3 "" H 12425 8225 50  0000 C CNN
-	1    12425 8225
-	1    0    0    -1
-$EndComp
 Text Notes 12075 7050 0    100  ~ 0
 Photodiode \nConditioned \nOutput
@@
 $EndComp
 $Comp
-L +5V #PWR019
+L +5V #PWR015
 U 1 1 5974FCB7
 P 2525 2700
-F 0 "#PWR019" H 2525 2550 50  0001 C CNN
+F 0 "#PWR015" H 2525 2550 50  0001 C CNN
 F 1 "+5V" H 2525 2840 50  0000 C CNN
 F 2 "" H 2525 2700 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR020
+L +5V #PWR016
 U 1 1 59752D6D
 P 1600 850
-F 0 "#PWR020" H 1600 700 50  0001 C CNN
+F 0 "#PWR016" H 1600 700 50  0001 C CNN
 F 1 "+5V" H 1600 990 50  0000 C CNN
 F 2 "" H 1600 850 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR021
+L GND #PWR017
 U 1 1 59753228
 P 2125 1250
-F 0 "#PWR021" H 2125 1000 50  0001 C CNN
+F 0 "#PWR017" H 2125 1000 50  0001 C CNN
 F 1 "GND" H 2125 1100 50  0000 C CNN
 F 2 "" H 2125 1250 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR022
+L GND #PWR018
 U 1 1 597544D0
 P 1600 1500
-F 0 "#PWR022" H 1600 1250 50  0001 C CNN
+F 0 "#PWR018" H 1600 1250 50  0001 C CNN
 F 1 "GND" H 1600 1350 50  0000 C CNN
 F 2 "" H 1600 1500 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR023
+L +5V #PWR019
 U 1 1 5981F754
 P 12650 8225
-F 0 "#PWR023" H 12650 8075 50  0001 C CNN
+F 0 "#PWR019" H 12650 8075 50  0001 C CNN
 F 1 "+5V" H 12650 8365 50  0000 C CNN
 F 2 "" H 12650 8225 50  0000 C CNN
@@
 	2525 3500 2525 3600
 Wire Wire Line
-	9325 7350 9325 7450
+	9325 7275 9325 7450
 Connection ~ 13325 8725
 Wire Wire Line
@@
 	12425 8725 13525 8725
 Wire Wire Line
-	12425 8325 12425 8225
-Wire Wire Line
 	12425 8325 13525 8325
 Wire Wire Line
@@
 	9025 6325 9025 6425
 Wire Wire Line
-	9550 6000 9550 5950
+	9550 5850 9550 6000
 Connection ~ 9550 6325
 Wire Wire Line
@@
 	10425 7175 10425 7150
 Wire Wire Line
-	10225 7075 10225 7625
+	10225 7025 10225 7625
 Wire Wire Line
 	13100 3925 13350 3925
@@
 Wire Wire Line
 	2825 3300 4350 3300
-$Comp
-L +3.3V #PWR024
-U 1 1 5983489F
-P 10225 7075
-F 0 "#PWR024" H 10225 6925 50  0001 C CNN
-F 1 "+3.3V" H 10225 7215 50  0000 C CNN
-F 2 "" H 10225 7075 50  0000 C CNN
-F 3 "" H 10225 7075 50  0000 C CNN
-	1    10225 7075
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	13350 3925 13350 5550
@@
 SHEET 2: SIGNAL CONDITIONING
 $Comp
-L AGND #PWR025
+L AGND #PWR020
 U 1 1 598790E7
 P 9325 8425
-F 0 "#PWR025" H 9325 8175 50  0001 C CNN
+F 0 "#PWR020" H 9325 8175 50  0001 C CNN
 F 1 "AGND" H 9325 8275 50  0000 C CNN
 F 2 "" H 9325 8425 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR026
+L AGND #PWR021
 U 1 1 598791DA
 P 12425 8775
-F 0 "#PWR026" H 12425 8525 50  0001 C CNN
+F 0 "#PWR021" H 12425 8525 50  0001 C CNN
 F 1 "AGND" H 12425 8625 50  0000 C CNN
 F 2 "" H 12425 8775 50  0000 C CNN
@@
 AGND
 $Comp
-L AGND #PWR027
+L AGND #PWR022
 U 1 1 598796DA
 P 4225 8475
-F 0 "#PWR027" H 4225 8225 50  0001 C CNN
+F 0 "#PWR022" H 4225 8225 50  0001 C CNN
 F 1 "AGND" H 4225 8325 50  0000 C CNN
 F 2 "" H 4225 8475 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR028
+L AGND #PWR023
 U 1 1 59879F07
 P 6350 4225
-F 0 "#PWR028" H 6350 3975 50  0001 C CNN
+F 0 "#PWR023" H 6350 3975 50  0001 C CNN
 F 1 "AGND" H 6350 4075 50  0000 C CNN
 F 2 "" H 6350 4225 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR029
+L AGND #PWR024
 U 1 1 5987A045
 P 3350 4900
-F 0 "#PWR029" H 3350 4650 50  0001 C CNN
+F 0 "#PWR024" H 3350 4650 50  0001 C CNN
 F 1 "AGND" H 3350 4750 50  0000 C CNN
 F 2 "" H 3350 4900 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR030
+L AGND #PWR025
 U 1 1 5987A135
 P 5175 5000
-F 0 "#PWR030" H 5175 4750 50  0001 C CNN
+F 0 "#PWR025" H 5175 4750 50  0001 C CNN
 F 1 "AGND" H 5175 4850 50  0000 C CNN
 F 2 "" H 5175 5000 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR031
+L AGND #PWR026
 U 1 1 5987A303
 P 2525 3600
-F 0 "#PWR031" H 2525 3350 50  0001 C CNN
+F 0 "#PWR026" H 2525 3350 50  0001 C CNN
 F 1 "AGND" H 2525 3450 50  0000 C CNN
 F 2 "" H 2525 3600 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR032
+L AGND #PWR027
 U 1 1 5987F0DC
 P 12225 4175
-F 0 "#PWR032" H 12225 3925 50  0001 C CNN
+F 0 "#PWR027" H 12225 3925 50  0001 C CNN
 F 1 "AGND" H 12225 4025 50  0000 C CNN
 F 2 "" H 12225 4175 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR033
+L AGND #PWR028
 U 1 1 5987F1D1
 P 12550 3650
-F 0 "#PWR033" H 12550 3400 50  0001 C CNN
+F 0 "#PWR028" H 12550 3400 50  0001 C CNN
 F 1 "AGND" H 12550 3500 50  0000 C CNN
 F 2 "" H 12550 3650 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR034
+L AGND #PWR029
 U 1 1 598809E6
 P 6675 3625
-F 0 "#PWR034" H 6675 3375 50  0001 C CNN
+F 0 "#PWR029" H 6675 3375 50  0001 C CNN
 F 1 "AGND" H 6675 3475 50  0000 C CNN
 F 2 "" H 6675 3625 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR035
+L AGND #PWR030
 U 1 1 5988572B
 P 10225 8125
-F 0 "#PWR035" H 10225 7875 50  0001 C CNN
+F 0 "#PWR030" H 10225 7875 50  0001 C CNN
 F 1 "AGND" H 10225 7975 50  0000 C CNN
 F 2 "" H 10225 8125 50  0000 C CNN
@@
 VREF
 $Comp
-L AGND #PWR036
+L AGND #PWR031
 U 1 1 598046F9
 P 2825 2950
-F 0 "#PWR036" H 2825 2700 50  0001 C CNN
+F 0 "#PWR031" H 2825 2700 50  0001 C CNN
 F 1 "AGND" H 2825 2800 50  0000 C CNN
 F 2 "" H 2825 2950 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR037
+L AGND #PWR032
 U 1 1 598047EC
 P 1700 3450
-F 0 "#PWR037" H 1700 3200 50  0001 C CNN
+F 0 "#PWR032" H 1700 3200 50  0001 C CNN
 F 1 "AGND" H 1700 3300 50  0000 C CNN
 F 2 "" H 1700 3450 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR038
+L AGND #PWR033
 U 1 1 5984484C
 P 10425 7375
-F 0 "#PWR038" H 10425 7125 50  0001 C CNN
+F 0 "#PWR033" H 10425 7125 50  0001 C CNN
 F 1 "AGND" H 10425 7225 50  0000 C CNN
 F 2 "" H 10425 7375 50  0000 C CNN
@@
 $EndComp
 $Comp
-L AGND #PWR039
+L AGND #PWR034
 U 1 1 5984493C
 P 10825 7375
-F 0 "#PWR039" H 10825 7125 50  0001 C CNN
+F 0 "#PWR034" H 10825 7125 50  0001 C CNN
 F 1 "AGND" H 10825 7225 50  0000 C CNN
 F 2 "" H 10825 7375 50  0000 C CNN
@@
 	1    0    0    -1
 $EndComp
+Text HLabel 13525 8325 2    50   Input ~ 0
+VDDANA
+Text Label 12425 8325 0    50   ~ 0
+VDDANA
+Wire Wire Line
+	9550 5850 9050 5850
+Text Label 9050 5850 0    50   ~ 0
+VDDANA
+Wire Wire Line
+	8950 7275 9325 7275
+Text Label 8950 7275 0    50   ~ 0
+VDDANA
+Wire Wire Line
+	10225 7025 9925 7025
+Text Label 9925 7025 0    50   ~ 0
+VDDANA
 $EndSCHEMATC

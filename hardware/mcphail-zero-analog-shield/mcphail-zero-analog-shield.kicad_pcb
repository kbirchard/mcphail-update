# Repository kbirchard/mcphail-update

File README.md:

# McPhail-Trap

- [Insect Wingbeat Frequencies Table](research/Wingbeat_Frequencies.md)

### Boards

[**Main Board**](hardware/mcphail-main-board/) (incomplete)
- Estimated boards cost $35 for three ($11.68 each)
- Estimated parts cost $50
- Not including the one FONA board and the 2200mAH LiPo we have on hand
- Board is 3.18x2.24 inches (80.82x56.79mm)

[**Emitter Board**](hardware/mcphail-ir-emitter-board/)

- Boards cost $6.85 for three ($2.28 each)
- Parts cost $4.51 for one board
- Board is 2.71x0.51 inches (68.76x12.88mm)

[**Detector Board**](hardware/mcphail-photodiode-detector-board/)

- Boards cost $6.80 for three ($2.27 each)
- Parts cost $15.16 for one board
- Board is 2.71x0.51 inches (68.76x12.88mm)

[**Generic ATSAM21G18 Breakout Board**](https://github.com/wickerbox/Basic-Breakout-Boards/tree/master/atsamd21g18-breakout)

- Boards cost $13.85 for three ($4.62 each)
- Parts cost $14.51 for one board

[**STLink/V2 SWD Adapter Board**](https://github.com/wickerbox/Basic-Breakout-Boards/tree/master/atsamd21g18-jtag-stlinkv2-adapter)

- Boards cost $8.80 for three ($2.93 each)
- Parts cost $2.22 for one board

## KiCad design hardware/mcphail-zero-analog-shield/mcphail-zero-analog-shield.kicad_pcb

Parts:
C1: 330uF; CAP-RADIAL-ALUM-D6.3MM-P2.5MM
C2: DNP; RLC-1206-SMD
C3: 220nF; RLC-0603-SMD
C4, C9, C14, C29: 1uF; RLC-0805-SMD
C5: 39nF; RLC-0603-SMD
C6, C15: 22uF; RLC-1210-SMD
C7, C11, C13: 1.5uF; RLC-1206-SMD
C8, C12, C28: 10nF; RLC-0603-SMD
C10: 270nF; RLC-0603-SMD
C16, C17, C19, C22: 2.2uF; RLC-0805-SMD
C18: 33pF; RLC-0603-SMD
C20, C21, C23, C24: 4.7uF; RLC-1206-SMD
C25: 10uF; RLC-0805-SMD
C26: 100nF; RLC-0603-SMD
C27: 22nF; RLC-0603-SMD
J1: INSECT DETECTION; CONN-ONSHORE-SCREW-GREEN-2PIN-TH
J2: EMITTERS; CONN-ONSHORE-SCREW-GREEN-2PIN-TH
J3: VREF; CONN-HEADER-STRAIGHT-P2.54MM-1x01
LED1: AMBER; LED-0603-SMD
R1, R32: 220; RLC-0603-SMD
R2: 64.9K; RLC-0603-SMD
R3, R4: 100K; RLC-0603-SMD
R5: 1.87K; RLC-0603-SMD
R6, R30: 3.83K; RLC-0603-SMD
R7: 10; RLC-0603-SMD
R8, R11: 1.43K; RLC-0603-SMD
R9: 1.02K; RLC-0603-SMD
R10: 732; RLC-0603-SMD
R12, R16, R23: 2.26K; RLC-0603-SMD
R13: 10K; RLC-0603-SMD
R14: 470; RLC-0603-SMD
R15: 97.6K; RLC-0603-SMD
R17: 68; RLC-0603-SMD
R18, R19: 91K; RLC-0603-SMD
R20, R21: 200K; RLC-0805-SMD
R22, R26: 2.2K; RLC-0603-SMD
R24, R28: 22K; RLC-0603-SMD
R25, R29: 4.32K; RLC-0603-SMD
R27: 2.94K; RLC-0603-SMD
R31: 0 ohm; RLC-0603-SMD
S1: RESET; SWITCH-OMRON-MOMENTARY-SMD-B3U-1000P
U1, U2: MCP6004; SOIC-14-3.9x8.7MM-P1.27MM
U3: TLV274; SOIC-14-3.9x8.7MM-P1.27MM
U4: MCP6001; SOT-23-5
U5: ARDUINO-101-SHIELD; ARDUINO-UNO-SHIELD

Connections:
+3V3: C25.1, C26.1, R18.1, R20.1, R31.1, U3.4 (+)
+5V: C1.1, C3.1, C14.1, C29.1, R1.1, R3.1, U1.4 (+), U2.4 (+), U4.5 (+), U5.5V
/A0: R28.1, U3.14, U5.A0
/A1: R26.1, R28.2, U3.13 (-), U5.A1
/A2: C22.1, R18.2, R19.1, R22.2, U5.A2
/LINE_IN: C18.1, C22.2, R15.1, U2.7
/PHOTO_K: C2.2, J1.1, R2.2, U4.4 (-)
/VREF: C5.2, C6.1, C9.1, C10.2, C27.2, J3.1, R7.1, R9.2, R14.2, R17.2, U1.3 (+), U1.5 (+), U1.10 (+), U2.3 (+), U2.5 (+), U2.10 (+), U2.12 (+)
GND: C1.2, C3.2, C4.2, C6.2, C9.2, C14.2, C25.2, C26.2, C29.2, J1.2, J2.2, R4.2, R19.2, R32.2, S1.2, U1.11 (-), U2.11 (-), U3.11 (-), U4.2 (-), U4.3 (+), U5.GND1 (GND), U5.GND2 (GND), U5.GND3 (GND)
unnamed: C2.1, C7.2, R2.1, U4.1
unnamed: C4.1, R3.2, R4.1, U1.12 (+)
unnamed: C5.1, R5.2, R6.2, R30.1
unnamed: C8.1, R6.1, R8.2, U2.14
unnamed: C8.2, R5.1, U2.13 (-)
unnamed: C10.1, R8.1, R10.2, R11.2
unnamed: C11.1, R12.2, U1.2 (-)
unnamed: C7.1, C11.2, C13.2, R9.1
unnamed: C12.1, C15.1, R11.1, U2.8
unnamed: C12.2, R10.1, U2.9 (-)
unnamed: C13.1, C16.2, R12.1, U1.1
unnamed: C15.2, R13.1
unnamed: C16.1, C17.2, C19.2, R14.1
unnamed: C17.1, R16.2, U1.6 (-)
unnamed: C18.2, R13.2, R15.2, U2.6 (-)
unnamed: C19.1, C20.2, R16.1, U1.7
unnamed: C20.1, C23.2, C24.2, R17.1
unnamed: C21.1, R20.2, R21.1, U3.5 (+)
unnamed: C21.2, R21.2
unnamed: C23.1, R23.2, U1.9 (-)
unnamed: C24.1, R23.1, R25.2, U1.8
unnamed: C27.1, R25.1, R27.2, R29.2
unnamed: C28.1, R29.1, R30.2, U2.1
unnamed: C28.2, R27.1, U2.2 (-)
unnamed: J2.1, R1.2
unnamed: LED1.1 (K), R32.1
unnamed: LED1.2 (A), U5.D7
unnamed: R7.2, U1.13 (-), U1.14
unnamed: R22.1, R24.2, U3.2 (-)
unnamed: R24.1, R26.2, U3.1
unnamed: R31.2, U5.3V3 (3.3V)
unnamed: S1.1, U5.RST (RESET)
unnamed: U3.3 (+), U3.6 (-), U3.7, U3.12 (+)

Notes on the sheet:
PHOTODIODE INPUT
Photodiode Conditioned Output
EMITTER OUTPUT
Vout = -Idiode * Rf Vout = -10uA * 64.9kohm Vout = -0.649V
https://electronics.stackexchange.com/questions/36086/does-this-photodiode-circuit-work
5V * (100K / 200K) = 2.5V
2.5V
VREF = 2.5V
130 Hz near -0.649V
NOTE: use a jumper from 5V or 3.3V or VREF to AREF as appropriate
TEST POINT

Board: 2 copper layers, 70.9 x 53.3 mm, 71 parts (0 on the bottom side), 42 nets.

## KiCad design hardware/mcphail-main-board/mcphail-main-board.kicad_pcb

File hardware/mcphail-main-board/README.md (part):

<!--- start title --->
# McPhail Trap Main Board v1.1
Collect, analyze, and report back environmental data.

- Updated: 12 Aug 2017
- Author: Jenner Hanni
- Website: http://wickerbox.net
- Company: Wickerbox Electronics
- License: CERN Open Hardware License v1.2
<!--- end title --->

This is an attempt to reproduce the work of identifying fruit flies from the following papers:

- 2017: [Automated Surveillance of Fruit Flies](http://www.mdpi.com/1424-8220/17/1/110/pdf)
- 2015: [Insect Biometrics: Optoacoustic Signal Processing and its Applications to Remote Monitoring](http://www.ncbi.nlm.nih.gov/pmc/articles/PMC4636391/)
- 2014: [The Electronic McPhail Trap](http://www.mdpi.com/1424-8220/14/12/22285) 
- 1979: [Optical Tachometer for Measurement of Wingbeat Frequency of Free-Flying Insects](http://jeb.biologists.org/content/82/1/377)

Parallels the European [ENTOMATIC](https://www.upf.edu/web/entomatic/) project.

## Hardware Version Notes

- v1.x, proof of concept, collect data on SD card and over USB
  Fona breakout board supports texting
- v2.x, switch to ARM MSP430 or other ADC-specific chip, collect data on SD card
- v3.x, integrate mesh net or other networking, possibly more sophisticated offboard analysis

\pagebreak

## Design Notes

### Physical Housing

Putting the electronics in acrylic separate from the insects so the ultrasonic isn't bothering them. An acrylic housing placed on top of the trap provides protection from the elements as well as protects the insects from any electronics noise. 

If all circuitry is on the board at the top, the IR emitters and photodiode detectors can be the only items in the trap with the insects and be connected by a minimum of cabling. 

The boards will all be 0.063" (1.6mm) thick FR-4 with purple solder mask over bare copper and an ENIG (gold) finish.

The tallest component on the board is C1 (330uF aluminum capacitor) at 0.5" tall.

**Board dimensions**

|Board|Dimensions|
|-----|----------|
|Emitter Board|2.71x0.51 inches (68.76x12.88mm)|
|Detector Board|2.71x0.51 inches (68.76x12.88mm)|
|Main Board|3.18x2.24 inches (80.82x56.79mm)|

### Security and Connectivity Platforms for reference

- Particle
- Electric Imp

### v1 FONA808 GSM+GPS MODULE

- PS is power status. Check this after toggling KEY.
   Pin is low when module is off, and high when module is on.

- NS is network status. It pulses to signal current module status

- RST is hard reset to be used only when module is really stuck.

- RX/TX are pins capable of Software Serial. They are auto-baud so
   whatever baud you send "AT" after reset or boot is the baud rate
   the module will use. 

- RTS is hardware flow control. Optional.
   Turn it on in module if you want to use it. 

- RI is the ring indicator output. Use it as an interrupt. Default high.
   Pin will pulse low for 120ms when a call or SMS is received. 

The GPS is accessible on the Rx/Tx lines so you can query
using AT commands and get the values back. No additional
pins are necessary.

### Microcontroller

The reference papers call for a 14-bit ADC.

The Atmel AVR chips we initially considered (Atmega32u4, Atmega2560) had 10-bit ADC, which isn't enough. We chose the ATSAMD21G Cortex M0 with 12-bit ADC since it still can be programmed with a cheap programmer, doesn't require dedicated hardware, has built-in USB for programming and monitoring.

It is compatible with [adalink](https://github.com/adafruit/Adafruit_Adalink) and [avrdude](http://www.nongnu.org/avrdude/), which we already use for programming other boards. 

We added a $6 16-bit ADS1115 which receives on two differential or four single channels (we could use the four) and outputs the result over I2C.
 
Another possible solution would have been the $6 MSP432 or a similar chip, could pick up a $14 dev board as well. This is a TI chip that requires CodeComposer Studio, newest version is CCSv6. It's Linux-compatible and I have a Windows machine just in case it's not.

The downside of the MSP432 is the $45 additional programmer we need to buy, getting set up with a new dev environment, etc.  

### ADC and Noise Notes

The 2-layer board is routed using a split ground plane to separate the analog and digital signals. Care was taken to provide clear analog return paths but the A0, A1, and A2 signals right at the microcontroller are next to the I2C signals and this may end up as a source of noise. 

If noise is still an issue, we may need need a 4-layer board (which doubles board cost). It's unclear if ENTOMATIC are actually getting and using all 14 bits. 

Does 5V in the ENTOMATIC system vs 3.3V in our system make a difference? How?

We need to review the ENTOMATIC calculations -- seems like my back-of-envelope has 32ms, not 16ms as from their paper.

For power and noise control, we should turn off everything but the ADC when sampling. 

[Discussion of cheap 16-bit ADC](http://www.avrfreaks.net/forum/cheap-16-bit-adc)

### Software Approach

We collect the value from the ADC in a variable and poll it at the desired rate. 

Architecture could be a finite state machine.

Next step is to go through and set up all the registers first to initialize serial comms, ADC, RTC, low power mode, the interrupts, and so on. Then, make sure we have libraries for accessing the SD, etc. This will not be an Arduino project, but an AVR GCC project. Need to get the environment set up and document it so someone else can reproduce the work in the same way we did.

### RTC

The DS1307 real time clock is out of date and hard to find.

We used the MCP7940N with an external 32.768kHz external crystal, following the suggested PCB layout on [page 14 of the datasheet](http://ww1.microchip.com/downloads/en/DeviceDoc/20005010F.pdf).

There is a discussion of digital trimming on page 29 to mitigate temperature and intrinsic clock issues. We can figure out the values in this digital trimming register by testing the physical board and calculating the the trim value with the equations on paeg 30. 

### Temperature

Kyle put a thermometer in the trap and measured the temperature inside over two days in direct sunlight. Both times the internal temp was 10 F degrees higher than the ambient air temp. (110/100F first day @ 5pm, 108/98F second day @ noon). 

Prior to measuring, he left the thermometer in the trap for an hour, so that should be a reflection of what we'd see in the field. The combination of size and materials is keeping the temperature from getting much higher.

### Capacitors

Mostly ceramic capacitors were chosen for cost and size, with C0G/NP0 and X7R temperature coefficients. Aluminum electrolytic capacitors were chosen where ceramics were cost-prohibitive or where specifically indicated in datasheets.

The temperature coefficients: 

X7R means a capacitor is a temperature-stable (EIA Class 2) cap which only varies up to ±15% from -55°C to +125°C.  [ref](http://www.avx.com/products/ceramic-capacitors/surface-mount/x7r-dielectric/)

C0G/NP0 means a capacitor is temperature-compensating (EIA Class 1) which varies less than ±0.3% C from -55°C to +125°C. Capacitance drift or hysteresis is less than ±0.05%. [ref](http://www.avx.com/products/ceramic-capacitors/surface-mount/c0g-np0-dielectric/)

## Detector/Receiver Board

Interestingly, the receiver part number [TEMD5080X01](https://www.digikey.com/product-detail/en/vishay-semiconductor-opto-division/TEMD5080X01/TEMD5080X01CT-ND/2747443?WT.srch=1&gclid=EAIaIQobChMI-f3J4Zml1QIV6wrTCh2xegkZEAAYAiAAEgK2kvD_BwE) does not have the same package as in the photos of the McPhail trap. These are $1.31 each at 25 and the design calls for ten of them. 

They are good from -40C to 100C and are 5mm x 4.24mm. 

The board is 2.71x0.51 inches (68.76x12.88mm) and costs $7 from OSH Park for a set of three ($2.33 each). 

The stencil costs $5 from OSH Stencils.

## Emitter Board

The 940nm emitters are in the $2 range and the board will probably be the same size as the detector board. 

Parts:
C1: 330uF; CAP-RADIAL-ALUM-D6.3MM-P2.5MM
C2: DNP; RLC-1206-SMD
C3: 220nF; RLC-0603-SMD
C4, C9, C14, C29: 1uF; RLC-0805-SMD
C5: 39nF; RLC-0603-SMD
C6, C15: 22uF; RLC-1210-SMD
C7, C11, C13: 1.5uF; RLC-1206-SMD
C8, C12, C28: 10nF; RLC-0603-SMD
C10: 270nF; RLC-0603-SMD
C16, C17, C19, C22: 2.2uF; RLC-1210-SMD
C18: 33pF; RLC-0603-SMD
C20, C21, C23, C24: 4.7uF; RLC-1206-SMD
C25: 10uF; RLC-0805-SMD
C26: 100nF; RLC-0603-SMD
C27: 22nF; RLC-0603-SMD
J1: INSECT DETECTION; CONN-HEADER-STRAIGHT-P2.54MM-1x02
J2: EMITTERS; CONN-HEADER-STRAIGHT-P2.54MM-1x02
J3: BREAKOUT; CONN-HEADER-STRAIGHT-P2.54MM-1x06
R1: 220; RLC-0603-SMD
R2: 64.9K; RLC-0603-SMD
R3, R4: 100K; RLC-0603-SMD
R5: 1.87K; RLC-0603-SMD
R6, R30: 3.83K; RLC-0603-SMD
R7: 10; RLC-0603-SMD
R8, R11: 1.43K; RLC-0603-SMD
R9: 1.02K; RLC-0603-SMD
R10: 732; RLC-0603-SMD
R12, R16, R23: 2.26K; RLC-0603-SMD
R13: 10K; RLC-0603-SMD
R14: 470; RLC-0603-SMD
R15: 97.6K; RLC-0603-SMD
R17: 68; RLC-0603-SMD
R18, R19: 91K; RLC-0603-SMD
R20, R21: 200K; RLC-0805-SMD
R22, R26: 2.2K; RLC-0603-SMD
R24, R28: 22K; RLC-0603-SMD
R25, R29: 4.32K; RLC-0603-SMD
R27: 2.94K; RLC-0603-SMD
U1, U2: MCP6004; SOIC-14-3.9x8.7MM-P1.27MM
U3: TLV274; SOIC-14-3.9x8.7MM-P1.27MM
U4: MCP6001; SOT-23-5

Connections:
+5V: C1.1, C3.1, C14.1, C29.1, J3.1, R1.1, R3.1, U1.4 (+), U2.4 (+), U4.5 (+); also elsewhere on the board
/A0: C22.1, J3.5, R18.2, R19.1, R22.2; also elsewhere on the board
/A1: J3.4, R26.1, R28.2, U3.13 (-); also elsewhere on the board
/A2: J3.3, R28.1, U3.14; also elsewhere on the board
/Photodiode Signal Input Conditioning/LINE_IN: C18.1, C22.2, R15.1, U2.7
/Photodiode Signal Input Conditioning/PHOTO_K: C2.2, J1.1, R2.2, U4.4 (-)
/Photodiode Signal Input Conditioning/VREF: C5.2, C6.1, C9.1, C10.2, C27.2, R7.1, R9.2, R14.2, R17.2, U1.3 (+), U1.5 (+), U1.10 (+), U2.3 (+), U2.5 (+), U2.10 (+), U2.12 (+)
/VDDANA: C25.1, C26.1, J3.2, R18.1, R20.1, U3.4 (+); also elsewhere on the board
AGND: C3.2, C4.2, C6.2, C9.2, C14.2, C25.2, C26.2, C29.2, J1.2, J3.6, R4.2, R19.2, U1.11 (-), U2.11 (-), U3.11 (-), U4.2 (-), U4.3 (+); also elsewhere on the board
GND: C1.2, J2.2; also elsewhere on the board
unnamed: C2.1, C7.2, R2.1, U4.1
unnamed: C4.1, R3.2, R4.1, U1.12 (+)
unnamed: C5.1, R5.2, R6.2, R30.1
unnamed: C8.1, R6.1, R8.2, U2.14
unnamed: C8.2, R5.1, U2.13 (-)
unnamed: C10.1, R8.1, R10.2, R11.2
unnamed: C11.1, R12.2, U1.2 (-)
unnamed: C7.1, C11.2, C13.2, R9.1
unnamed: C12.1, C15.1, R11.1, U2.8
unnamed: C12.2, R10.1, U2.9 (-)
unnamed: C13.1, C16.2, R12.1, U1.1
unnamed: C15.2, R13.1
unnamed: C16.1, C17.2, C19.2, R14.1
unnamed: C17.1, R16.2, U1.6 (-)
unnamed: C18.2, R13.2, R15.2, U2.6 (-)
unnamed: C19.1, C20.2, R16.1, U1.7
unnamed: C20.1, C23.2, C24.2, R17.1
unnamed: C21.1, R20.2, R21.1, U3.5 (+)
unnamed: C21.2, R21.2
unnamed: C23.1, R23.2, U1.9 (-)
unnamed: C24.1, R23.1, R25.2, U1.8
unnamed: C27.1, R25.1, R27.2, R29.2
unnamed: C28.1, R29.1, R30.2, U2.1
unnamed: C28.2, R27.1, U2.2 (-)
unnamed: J2.1, R1.2
unnamed: R7.2, U1.13 (-), U1.14
unnamed: R22.1, R24.2, U3.2 (-)
unnamed: R24.1, R26.2, U3.1
unnamed: U3.3 (+), U3.6 (-), U3.7, U3.12 (+)

Notes on the sheet:
PHOTODIODE INPUT
Photodiode Conditioned Output
EMITTER OUTPUT
SHEET 2: SIGNAL CONDITIONING
Vout = -Idiode * Rf Vout = -10uA * 64.9kohm Vout = -0.649V
https://electronics.stackexchange.com/questions/36086/does-this-photodiode-circuit-work
5V * (100K / 200K) = 2.5V
2.5V
VREF = 2.5V
130 Hz near -0.649V

Parts:
BAT1: 3V; BATT-HOLDER-CR1220-BK-916
C30, C36, C37, C38, C39, C51, C52: 100nF; RLC-0603-SMD
C31: 10uF; RLC-0805-SMD
C33, C35: 22pF; RLC-0603-SMD
C34: 1uF; RLC-0805-SMD
C40, C42: 2pF; RLC-0603-SMD
C41: 100pF; RLC-0603-SMD
D1: 20V 1A; DIODE-SMA
D2, D3: CG0603MLC-05E; RLC-0603-SMD
F1: 500mA; RLC-1812-SMD
FID1, FID2, FID3: FIDUCIAL; FIDUCIAL-2MM
J4: MICRO SD; CONN-SD-MICRO-MOLEX-0475710001
J5: MICRO USB; CONN-USB-MICRO-B-AMPHENOL-10118193-0001LF
J6: PROG/BOOT; CONN-HEADER-STRAIGHT-P2.54MM-2x03
J7: FONA 808; BREAKOUT-ADAFRUIT-FONA808-CELL-GPS
L1, L3, L4, L5: FERRITE; RLC-0805-SMD
R31: 330; RLC-0603-SMD
R32, R37: 1K; RLC-0603-SMD
R33, R36: 10K; RLC-0603-SMD
R34, R35: 2K; RLC-0603-SMD
S1: RESET; SWITCH-OMRON-MOMENTARY-SMD-B3U-1000P
U5: ADS1118; MSOP-10-3x3MM-P0.5MM
U6: ATSAMD21G18A; TQFP-48_7x7mm_Pitch0.5mm
U7: 24AA1025 EEPROM; SOIC-8-3.9x4.9MM-P1.27MM
U8: MCP7940N RTC; SOIC-8-3.9x4.9MM-P1.27MM
X1: 16MHz; CRYSTAL-CTS-4SMD
X2: 32.768kHz; CRYSTAL-HC49-TH

Connections:
+3V3: C30.1, C36.1, C37.1, C38.1, C39.1, J4.4 (VCC), J6.1, J7.4 (Vio), L4.2, R32.1, R33.1, R34.1, R35.1, R36.1, U5.7 (AIN3), U5.8 (VDD), U6.17 (VDDIO), U6.36 (VDDIO), U6.44 (VDDIN), U7.8 (VCC), U8.8 (VCC); also elsewhere on the board
+5V: J7.1 (5V); also elsewhere on the board
/A0: U5.4 (AIN0), U6.12 (PA07/AIN7); also elsewhere on the board
/A1: U5.5 (AIN1), U6.11 (PA06/AIN6); also elsewhere on the board
/A2: U5.6 (AIN2), U6.10 (PA05/AIN5); also elsewhere on the board
/Microcontroller/D4_CS: U5.2 (~CS), U6.13 (PA08/I2C/AIN16)
/Microcontroller/D7_CS: J4.2 (CS), U6.25 (PA16/I2C)
/Microcontroller/D+: D3.1, J5.3 (D+), U6.34 (PA25/USBDP)
/Microcontroller/D-: D2.1, J5.2 (D-), U6.33 (PA24/USBDM)
/Microcontroller/EEPROM_ADD0: U6.39 (PA27), U7.1 (A0)
/Microcontroller/EEPROM_ADD1: U6.38 (PB23), U7.2 (A1)
/Microcontroller/EEPROM_ADD2: U6.37 (PB22), U7.3 (A2)
/Microcontroller/FONA_NS: J7.12 (NS), U6.26 (PA17/I2C)
/Microcontroller/FONA_PS: J7.11 (PS), U6.27 (PA18)
/Microcontroller/FONA_RI: J7.10 (RI), U6.28 (PA19)
/Microcontroller/FONA_RST: J7.5 (RST), U6.32 (PA23/I2C/USBSOF)
/Microcontroller/FONA_RTS: J7.8 (RTS), U6.29 (PA20)
/Microcontroller/FONA_RX: J7.6 (RX), U6.31 (PA22/I2C)
/Microcontroller/FONA_TX: J7.7 (TX), U6.30 (PA21)
/Microcontroller/MFP: R36.2, U6.20 (PB11), U8.7 (MFP)
/Microcontroller/MISO: J4.7 (DATA_OUT), U5.9 (MISO/~DRDY), U6.15 (PA10/AIN18)
/Microcontroller/MOSI: J4.3 (DATA_IN), U5.10 (MOSI), U6.19 (PB10)
/Microcontroller/SCL: R34.2, U6.22 (PA13/I2C), U7.6 (SCL), U8.6 (SCL)
/Microcontroller/SCLK: J4.5 (SCLK), U5.1 (SCLK), U6.14 (PA09/I2C/AIN17)
/Microcontroller/SDA: R35.2, U6.21 (PA12/I2C), U7.5 (SDA), U8.5 (SDA)
/Microcontroller/SWCLK: J6.4, R32.2, U6.45 (PA30/SWCLK)
/Microcontroller/SWDIO: J6.2, U6.46 (PA31/SWDIO)
/Microcontroller/VUSB_IN: F1.2, J5.1 (VCC)
/Microcontroller/~RESET: C51.1, J6.6, R31.1, R33.2, U6.40 (~RESET)
/VDDANA: C31.1, C52.1, L4.1, U6.6 (VDDANA); also elsewhere on the board
/~PG: U6.41 (PA28); also elsewhere on the board
AGND: C30.2, C31.2, C52.2, L3.2, L5.2, U5.3 (GND), U6.5 (GNDANA); also elsewhere on the board
GND: BAT1.GND, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C51.2, D2.2, D3.2, J4.6 (VSS), J6.5, J7.3 (GND), J7.9 (KEY), L1.2, L3.1, L5.1, S1.2, U6.18 (GND), U6.35 (GND), U6.42 (GND), U7.4 (GND), U7.7 (WP), U8.4 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: BAT1.1, C41.1, R37.2
unnamed: C33.1, U6.23 (PA14/XIN), X1.1 (EN)
unnamed: C34.1, U6.43 (VDDCORE)
unnamed: C35.1, U6.24 (PA15/XOUT), X1.3 (OUT)
unnamed: C40.1, U8.2 (X2), X2.1
unnamed: C42.1, U8.1 (X1), X2.2
unnamed: D1.2 (A), F1.1
unnamed: J5.5 (GND), L1.1
unnamed: R31.2, S1.1
unnamed: R37.1, U8.3 (VBAT)
VUSB: D1.1 (K); also elsewhere on the board

Notes on the sheet:
RTC
EEPROM
CELL
ATSAM21G18 Cortex M0 (Arduino-compatible)
SHEET 3: MICROCONTROLLER
16-bit ADC
MicroSD
and Temp Sensor
5V is to charge the Fona's 3.7V LiPO Battery Vio sets the voltage level for the Fona pins to 3.3V

Parts:
B1: LIPO
C43, C44, C45: 4.7uF; RLC-1206-SMD
C46, C53: 10uF; RLC-0805-SMD
C47: 100nF; RLC-0603-SMD
C48: 10pF; RLC-0603-SMD
C49, C50: 1uF; RLC-0805-SMD
C54, C55, C56: 22uF; RLC-1210-SMD
D4: 20V 1A; DIODE-SMA
J8: INPUT 6V-9V; CONN-BARREL-JACK-2.5x5.5MM-TH
J9: JST PH; CONN-JST-S2B-PH-SM4-TB
L2: 1uH 3.3A; 1226AS-H-1R0N
LED1, LED2, LED3: AMBER; LED-0603-SMD
R38: 0 ohm; RLC-0603-SMD
R39, R40, R41: 470; RLC-0603-SMD
R42: NTC 10K; RLC-0402-SMD
R43: 2K; RLC-0603-SMD
R44: 100K; RLC-0603-SMD
R45, R47: 1M; RLC-0603-SMD
R46: 111K; RLC-0603-SMD
U9: MCP73871; QFN-20-1EP-4x4MM_P0.5MM
U10: BUCK-BOOST 5V TPS63060; WSON-10-1EP
U11: MCP1703; SOT-23-3
W1: TEST_1P; HOLE-PLATED-40MIL

Connections:
+3V3: C50.1, U11.2 (OUT); also elsewhere on the board
+5V: C49.1, C54.1, C55.1, C56.1, R45.1, R47.1, U10.9 (VOUT), U11.3 (IN); also elsewhere on the board
/Input Power/PROG1: R43.1, U9.13 (PROG1)
/Input Power/PROG3: R44.1, U9.12 (PROG3)
/Input Power/STAT1: R39.2, U9.8 (STAT1)
/Input Power/STAT2: R40.2, U9.7 (STAT2)
/Input Power/THERM: R42.1, U9.5 (THERM), W1.1
/Input Power/VCC: C44.1, C46.1, C53.1, U9.1 (OUT), U9.20 (OUT), U10.2 (VIN), U10.3 (EN)
/Input Power/~PG1: R41.2, U9.6 (~PG)
/~PG: C48.2, R46.2, R47.2, U10.5 (PG); also elsewhere on the board
GND: C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C50.2, C53.2, C54.2, C55.2, C56.2, J8.2, J8.3, J9.2, R42.2, R43.2, R44.2, U9.3 (SEL), U9.9 (~TE), U9.10 (VSS), U9.11 (VSS), U9.21 (VSS), U10.4 (PS/SYNC), U10.7 (GND), U10.11 (PGND), U11.1 (GND); also elsewhere on the board
unnamed: C47.1, U10.6 (VAUX)
unnamed: C48.1, R45.2, R46.1, U10.8 (FB)
unnamed: D4.2 (A), J8.1
unnamed: L2.1, U10.1 (L1)
unnamed: L2.2, U10.10 (L2)
unnamed: LED1.1 (K), R39.1
unnamed: LED2.1 (K), R40.1
unnamed: LED3.1 (K), R41.1
VBAT: C45.1, J9.1, U9.14 (VBAT), U9.15 (VBAT), U9.16 (VBAT_SENSE)
VIN: D4.1 (K), LED1.2 (A), LED2.2 (A), LED3.2 (A), R38.1, U9.2 (VPCC), U9.4 (PROG2), U9.17 (CE), U9.18 (IN), U9.19 (IN)
VUSB: C43.1, R38.2; also elsewhere on the board

Notes on the sheet:
VPCC DISABLED
IF VIN EXISTS, VCC = VIN (5V-9V) IF VIN REMOVED, VCC = VBAT (3.0V-4.2V) SEL set to USB 500mA charge limit ~TE~ low, enables safety timer
3.7V
SHEET 4: POWER INPUT
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
Board: 2 copper layers, 80.6 x 56.6 mm, 143 parts (1 on the bottom side), 93 nets.

Notices in the files:
hardware/mcphail-zero-analog-shield/mcphail-zero-analog-shield.kicad_pcb:
Released under the CERN Open Hardware License v1.2

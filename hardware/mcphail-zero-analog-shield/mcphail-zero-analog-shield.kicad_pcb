# Repository kbirchard/mcphail-update (continued)

## KiCad design hardware/mcphail-photodiode-detector-board/mcphail-photodiode-detector-board.kicad_pcb

File hardware/mcphail-photodiode-detector-board/README.md:

<!--- start title --->
# McPhail IR Detector Board v1.0
Part of the McPhail Trap Design

- Updated: 14 Aug 2017

- Author: Jenner Hanni
- Website: http://wickerbox.net
- Company: Wickerbox Electronics
- License: CERN Open Hardware License v1.2
<!--- end title --->

<!--- bom start --->
### Bill of Materials

|Ref|Qty|Description|Digikey PN|
|---|---|-----------|------|
|J1|1|HEADER MALE 2POS TH 1x02 0.1IN|952-2262-ND|
|LED1 LED10 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9|10|PHOTODIODE IR 940NM SMD TEMD5110X01|751-1048-1-ND|

<!--- bom end --->
<!--- assy start --->

<!--- assy end --->

Parts:
J1: TO MCU; CONN-HEADER-STRAIGHT-P2.54MM-1x02
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10: 940NM; TEMD5110X01

Connections:
/A: J1.1, LED1.2, LED2.2, LED3.2, LED4.2, LED5.2, LED6.2, LED7.2, LED8.2, LED9.2, LED10.2
/K: J1.2, LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED7.1, LED8.1, LED9.1, LED10.1

Board: 2 copper layers, 68.6 x 12.7 mm, 11 parts (0 on the bottom side), 2 nets.

File hardware/mcphail-ir-emitter-board/bom/mcphail-ir-emitter-board-v1.0-bom-master.csv:

Ref,Qty1,Qty3,Footprint,Footprint Library,Symbol,Symbol Library,Datasheet,MF_Name,MF_PN,S1_Name,S1_PN,Type
J1,1,3,CONN-HEADER-STRAIGHT-P2.54MM-1x02,Wickerlib,HEADER-MALE-2POS-TH-1x02-P0.1IN,wickerlib,https://cdn.harwin.com/pdfs/60page140.pdf,Harwin,M20-9990246,Digikey,952-2262-ND,
LED1 LED10 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9,10,30,LED-D5MM-2PIN-SH4356,Wickerlib,LED-IR-850NM-2PIN-TH-SFH4356,wickerlib,http://www.mouser.com/ds/2/311/SFH%204356,%20Lead%20(Pb%20Free%20Product%20-%20RoHS%20Compliant-532102.pdf,OSRAM Opto,SFH 4356,Mouser,720-SFH4356,

## KiCad design hardware/mcphail-ir-emitter-board/mcphail-ir-emitter-board.kicad_pcb

File hardware/mcphail-ir-emitter-board/README.md:

<!--- start title --->
# McPhail IR Emitter Board v1.0
Part of the McPhail Trap design

- Updated: 14 Aug 2017

- Author: Jenner Hanni
- Website: http://wickerbox.net
- Company: Wickerbox Electronics
- License: CERN Open Hardware License v1.2
<!--- end title --->

<!--- bom start --->
### Bill of Materials

|Ref|Qty|Description|Digikey PN|
|---|---|-----------|------|
|J1|1|HEADER MALE 2POS TH 1x02 0.1IN|952-2262-ND|

|Ref|Qty|Description|Mouser PN|
|---|---|-----------|------|
|LED1 LED10 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9|10|LED IR 850NM TH SFH4356|720-SFH4356|

<!--- bom end --->
<!--- assy start --->
<!--- assy end --->

Parts:
J1: TO MCU; CONN-HEADER-STRAIGHT-P2.54MM-1x02
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10: IR 850NM; LED-D5MM-2PIN-SH4356

Connections:
unnamed: J1.1, LED1.2
unnamed: J1.2, LED10.1
unnamed: LED1.1, LED2.2
unnamed: LED2.1, LED3.2
unnamed: LED3.1, LED4.2
unnamed: LED4.1, LED5.2
unnamed: LED5.1, LED6.2
unnamed: LED6.1, LED7.2
unnamed: LED7.1, LED8.2
unnamed: LED8.1, LED9.2
unnamed: LED9.1, LED10.2

Board: 2 copper layers, 68.6 x 12.7 mm, 11 parts (0 on the bottom side), 11 nets.

File hardware/mcphail-ir-emitter-board/bom/mcphail-ir-emitter-board-v1.0-bom-mouser.csv:

Ref,Qty,Qty3,Description,Mouser PN
LED1 LED10 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9,10,30,LED IR 850NM TH SFH4356,720-SFH4356

## Commit log

2017-07-03 Added paper.
2017-07-20 Added PDFs.
2017-07-20 Preliminary readme. No links yet.
2017-07-20 Remove .net from .gitignore. We need this file.
2017-07-20 Add Main Board started (photo conditioning).
2017-07-25 Release main board sch with BOM and layout estimates.
2017-07-25 Updated README to include hardware design notes.
2017-07-25 Add link from front README.
2017-07-25 Added another option for more ADC bits with Atmega32u4.
2017-07-27 Added ADS1118 (ADC with temp sensor) to Atmega32u4.
2017-07-27 Switched all to 3.3V, things got simple, cheaper.
2017-07-27 Hooked up pins to ATSAMD21G18 Cortex M0, fixed AGND throughout.
2017-07-27 Regenerated schematic PDF.
2017-07-30 Fixed the sigcond sch, VREF now correct.
2017-07-30 All footprints good. Changed op amps slightly for footprints.
2017-07-30 Basic parts grouping done.
2017-07-30 Sch passes rule check. Final netlist. Starting layout.
2017-07-30 Add files via upload
    Wingbeat frequencies from Table 1 in Byrne Buchmann & Spangler (1988)
2017-07-30 Update README.md
    Insect wingbeat table taken from Byrne, Buchmann & Spangler paper
2017-07-30 Add files via upload
    Insect wingbeat frequencies paper
2017-08-06 Removed emitter board project.
2017-08-06 Lots more layout work, needs rework.
2017-08-06 Add datasheet.
2017-08-06 Create emitter schematic.
2017-08-06 Add receiver schematic.
2017-08-06 Release v1.0 Mcphail IR 940nm Emitter Board.
2017-08-06 Release v1.0 Mcphail IR 940nm Detector Board.
2017-08-06 Add more datasheets.
2017-08-06 Saving main board layout before major rework.
2017-08-06 Regenerated sch pdf. Converted to 4 layer.
2017-08-06 Reworking main board, power rails routed next.
2017-08-06 Regenerated BOMs. Added links to README.
2017-08-09 Generate Main Board with traces done. Needs silk.
2017-08-09 Major updates to README.
2017-08-09 Updated REAME.
2017-08-09 Commit.
2017-08-12 Release v1.0 McPhail Main Board
2017-08-14 Release v1.0 McPhail IR Emitter Board
2017-08-14 Release v1.0 McPhail Photodiode Detector Board
2017-08-14 Automating more of the documentation.
2017-08-24 Added pin list.
2017-08-30 temp
2017-09-24 Fixed clearance issues on McPhail Main v1.1
2017-09-27 Add rough test plan.
2017-09-27 Fix DRC errors, regenerate gerbers. Order boards.
2017-10-03 Add schematic. Add layout - needs modified.
2017-10-03 Schematic ref des seems okay.
2017-10-03 Only comps we need left on board. Needs routed.
2017-10-03 Parts on board with no traces, clean. Ready to layout.
2017-10-03 Starting layout.
2017-10-03 More placement.
2017-10-03 Re-import netlist, override existing.
2017-10-04 Arduino Zero Shield v1.0 layout done.
2017-10-05 Zero shield v1.0 ready to order.
2018-02-09 Add datasheet. Fix footprint.
2019-04-12 Project report by Jared Rees
